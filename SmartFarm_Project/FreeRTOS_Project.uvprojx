# Keil uVision project FreeRTOS_Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FreeRTOS_Project +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group Source Group 1
    ./: uart.h uart.c Servo.c Servo.h BEEP.c BEEP.h Tpye.h
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c led_thread_entry.c new_thread0_entry.c.bak BLT_thread_entry.c Control_thread_entry.c Input_thread_entry.c.bak Screen_thread_entry.c Senor_thread_entry.c uart_thread_entry.c.bak
  group rainfall
    ./: rainfall.c rainfall.h
  group ADC0
    ./: adc_solidmoisture.c adc_solidmoisture.h adc0.c adc0.h
  group DTC
    ./: DTC.c DTC.h
  group pump
    ./: pump.c pump.h
software components: Flex Software:RA Configuration 1.0.0
