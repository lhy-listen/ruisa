# Keil uVision project DTC_ADC_DMA.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: DTC_ADC_DMA +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
  group rainfall
    ./: rainfall.c rainfall.h
  group uart
    ./: uart2.c uart2.h
  group ADC0
    ./: adc0.c adc0.h adc_solidmoisture.c adc_solidmoisture.h
  group DTC
    ./: DTC.c DTC.h
  group pump
    ./: pump.c pump.h
  group bh1750
    ./: bh1750.c bh1750.h
  group i2c4
    ./: i2c4.c i2c4.h
software components: Flex Software:RA Configuration 1.0.0
